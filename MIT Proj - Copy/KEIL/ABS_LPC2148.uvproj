# Keil uVision project ABS_LPC2148.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2138 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: ABS_LPC2148 +hex
  AfterMake: fromelf --bin .\ABSLPC2148.axf -o .\ABSLPC2148.bin
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s ABSLPC2148.c
